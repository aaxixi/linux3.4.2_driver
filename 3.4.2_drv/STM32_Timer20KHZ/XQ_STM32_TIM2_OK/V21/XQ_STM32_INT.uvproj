# Keil uVision project XQ_STM32_INT.uvproj, settings and files
target XQ_STM32_INT (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: XQ_STM32_INT +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Core;.\STM32_FWLib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group STM32_FWLib
    ./STM32_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
